# Repository elight2/PowerSupply

## KiCad design pcb/PowerSupply.kicad_pcb

Parts:
C1: 47p; C_0805_2012Metric
C2, C7: 1u; C_0805_2012Metric
C3: 100n 63V; C_0805_2012Metric
C4: 330n; C_0805_2012Metric
C5, C6, C13: 100n; C_0805_2012Metric
C8, C9, C10, C11, C15, C16, C18, C19, C20, C21: 2.2u 100V; C_1206_3216Metric
C12: 33n; C_0805_2012Metric
C14: 10n; C_0805_2012Metric
C17: 330p; C_0805_2012Metric
C22: 470p; C_0805_2012Metric
C23, C24, C25, C26, C27, C28, C29: 100u 63V; CP_Elec_8x10.5
D1: SS14; D_SMA
D2, D3: SS310; D_SMA
D4: LED; LED_0805_2012Metric
D6: D_Zener; D_SOD-123
L1: 3.3u; L_TaiTech_TMPC1265_13.5x12.5mm
Q1, Q2, Q3, Q4: Q_NMOS; TDSON-8_L5.9-W5.2-P1.27-BL-1
Q6: Q_PMOS; DFN-8_L5.8-W4.9-P1.27-LS6.1-BL-2
R1, R2, R8, R11: 100; R_1206_3216Metric
R3: 249k; R_1206_3216Metric
R4: 75k; R_1206_3216Metric
R5: 10R; R_1206_3216Metric
R6, R9: 3m; R_2512_6332Metric
R7: 93.1k; R_1206_3216Metric
R10: 2k; R_1206_3216Metric
R12: 20k; R_1206_3216Metric
R13: 1.5k; R_1206_3216Metric
R14, R24, R25: 5.1k; R_1206_3216Metric
RV1, RV2: 100k; RES-ADJ-TH_RK097111080R
SW1: SW_Push_DPDT; SW-SMD_6P-L9.1-W3.5-P2.50
U1: LM5176PWP; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP3.4x9.5mm_ThermalVias

Connections:
/BIAS: C13.2, U1.24 (BIAS)
/BOOT1: C5.2, D2.1 (K), U1.26 (BOOT1)
/BOOT2: C6.2, D3.1 (K), U1.20 (BOOT2)
/COMP: C12.2, C17.2, U1.9 (COMP)
/CS: C1.2, R1.2, U1.16 (CS)
/CSG: C1.1, R2.2, U1.15 (CSG)
/DITH: C14.2, U1.5 (DITH)
/EN_UVLO: R3.1, R4.2, U1.1 (EN/UVLO)
/FB: R13.2, RV2.3, U1.11 (FB)
/HDRV1: Q1.G, U1.27 (HDRV1)
/HDRV2: Q3.G, U1.19 (HDRV2)
/INPUT: C9.2, C11.2, C16.2, C19.2, C21.2, C24.1, D1.2 (A), Q1.D, Q6.D, R3.2, R10.2
/ISNS+: C7.1, R8.2, U1.14 (ISNS(+))
/ISNS-: C7.2, R11.2, U1.13 (ISNS(-))
/LDRV1: Q2.G, U1.25 (LDRV1)
/LDRV2: Q4.G, U1.21 (LDRV2)
/MODE: R7.2, U1.4 (MODE)
/PGOOD: D4.2 (A), R14.1, U1.17 (PGOOD)
/RT_SYNC: RV1.1, RV1.2, U1.6 (RT/SYNC)
/SLOPE: C22.2, U1.7 (SLOPE)
/SS: C4.2, U1.8 (SS)
/SW1: C5.1, L1.1, Q1.S, Q2.D, U1.28 (SW1)
/SW2: C6.1, L1.2, Q3.S, Q4.D, U1.18 (SW2)
/VCC: C2.2, D2.2 (A), D3.2 (A), U1.23 (VCC)
/VIN: C3.2, R5.1, U1.2 (VIN)
/VISNS: R10.1, U1.3 (VISNS)
GND: C2.1, C3.1, C4.1, C13.1, C14.1, C17.1, C22.1, D4.1 (K), R4.1, R7.1, R12.1, R13.1, R25.1, RV1.3, U1.10 (AGND), U1.29 (PowerPAD); also elsewhere on the board
GNDPWR: C8.1, C9.1, C10.1, C11.1, C15.1, C16.1, C18.1, C19.1, C20.1, C21.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, R2.1, R6.1, U1.22 (PGND)
LM5176_VOUT: C8.2, C10.2, C15.2, C18.2, C20.2, C23.1, C25.1, C26.1, C27.1, C28.1, C29.1, R9.2, R11.1, R14.2, RV2.1, RV2.2, U1.12 (VOSNS)
unnamed: C12.1, R12.2
unnamed: D1.1 (K), R5.2
unnamed: D6.2 (A), Q6.G, SW1.2 (B), SW1.5 (B)
unnamed: Q2.S, Q4.S, R1.1, R6.2
unnamed: Q3.D, R8.1, R9.1
unnamed: R24.1, SW1.1 (A), SW1.4 (A)
unnamed: R25.2, SW1.3 (C), SW1.6 (C)
USB_VBUS: D6.1 (K), Q6.S, R24.2; also elsewhere on the board

Notes on the sheet:
输入滤波 电容最低20V
频率补偿
电源RC滤波 二极管需耐压20V， 且小于0.8V压降
输入电压检测脚 2k电阻只在vo大于40V时需要
开关电路 MOS需N，且耐压55V 大电感减小最大电压差，减小纹波 小电感增加响应速度
电压反馈（调电压）
模式选择 开启hiccup和CCM
低压供电 暂时不连， 因为找不到合适电源
频率抖动
输出滤波 电容最低55V
使用PMOS的开关，稳压管用来防止GS击穿
VCC滤波 VCC用于充电两个自举电容
延迟启动
开机电压设置 低压保护
PGOOD上拉+ PGOOD指示灯
自举电容， 驱动H部分MOS 二极管需耐压55V 电容耐压16V
斜坡补偿 用于抑制D超过50%时的震荡
输出电流感知 （限流电路） 采样电阻暂时短接
电感电流采样电路 的滤波
开关频率调节 这里的电位器已经超出范围， 暂时不管

Parts:
C30: 1u; C_0805_2012Metric
D5: LED; LED_0805_2012Metric
J2: USB_C_Receptacle_USB2.0_16P; USB-C-SMD_HH-16P-CB-TYPE-C
R15: 1k; R_0805_2012Metric
R16, R18, R19, R20: 10k; R_0805_2012Metric
R17: 5.1k; R_0805_2012Metric
SW2: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W8.61mm_P2.54mm_LowProfile
U2: CH224K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm

Connections:
GND: C30.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), R18.2, R19.2, R20.2, U2.11 (GND); also elsewhere on the board
unnamed: D5.2 (A), R17.2
unnamed: D5.1 (K), U2.10 (PG)
unnamed: J2.A5 (CC1), U2.7 (CC1)
unnamed: J2.B5 (CC2), U2.6 (CC2)
unnamed: R18.1, SW2.1, U2.9 (CFG1)
unnamed: R19.1, SW2.2, U2.2 (CFG2)
unnamed: R20.1, SW2.3, U2.3 (CFG3)
unnamed: J2.A7 (D-), J2.B7 (D-), U2.5 (DM)
unnamed: J2.A6 (D+), J2.B6 (D+), U2.4 (DP)
unnamed: R16.2, U2.8 (VBUS)
unnamed: C30.2, R15.2, SW2.4, SW2.5, SW2.6, U2.1 (VDD)
USB_VBUS: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R15.1, R16.1, R17.1; also elsewhere on the board

Board: 4 copper layers, 96.8 x 96.8 mm, 71 parts (0 on the bottom side), 48 nets.

## Commit log

2026-03-21 Add LCSC C51661 TO-263-5 footprint
2026-03-24 添加子图 添加设计参数 修改en/uvlo 修改ss 更新10.0
2026-03-25 boot vcc
2026-03-26 first teach
2026-03-26 BIAS电路 MOS选择
2026-03-26 删lck
2026-03-27 mos电路
2026-03-27 频率，指示灯电路
2026-03-27 限流，抖动
2026-03-28 很多东西
2026-03-30 所有封装
2026-04-05 调整元件参数
2026-04-05 翻译指南
2026-04-11 提交信息
2026-04-11 添加6p typec沉板
2026-04-12 修6p typec封装
2026-04-12 pcb初版
2026-04-12 ch224k_pcb
2026-04-13 总开关电路
2026-04-15 整理封装
2026-04-15 ch224k
2026-04-15 还是ch224k
2026-04-16 再修ch224k
2026-04-16 更新PCB布局
2026-04-19 pcb布局调整
2026-04-23 改用lceda
2026-04-23 删除~文件
2026-05-20 添加仿真
2026-05-24 重新设计
